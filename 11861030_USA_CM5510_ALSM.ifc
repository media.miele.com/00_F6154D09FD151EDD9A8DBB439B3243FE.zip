Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2022-11-16T17:05:46
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Nov 16 17:05:46 2022 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\4b5687af-924a-4268-81d4-43609dcc3084\3d66d9f8-e700-46fe-9325-3e58765eb9c6\ifc * Database version: 5507 * Database creation date: Wed Nov 16 17:05:46 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Nov 16 17:05:46 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Nov 16 17:05:46 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11861030_USA_CM5510_ALSM:29551008_USA_11861030_CM5510_ALSM, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom
Type - Pset_BuildingElementProxyCommon - Reference: 29551008_USA_11861030_CM5510_ALSM
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_QuantityTakeOff - Reference: 29551008_USA_11861030_CM5510_ALSM
Type - Pset_ProvisionForVoid - Width: 241 mm; Height: 360 mm; Depth: 460 mm
Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_OBSW, z_Miele_Design_Zinc_Steel, z_Miele_Design_CLST, z_Miele_Design_Glass Black, z_Miele_Connection_Electric
Pset_BuildingElementProxyCommon - sets with these values: 2
